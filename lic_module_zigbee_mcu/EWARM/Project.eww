<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\lic_module_zigbee_mcu.ewp</path>
  </project>
  <batchBuild />
</workspace>
