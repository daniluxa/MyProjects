# IAR project lic_module_zigbee_mcu.ewp, settings and files
configuration lic_module_zigbee_mcu (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ZIGBEE_WB; USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/extras; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zgp; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Utilities/sequencer; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/mac; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/key; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/se; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/security; ../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/general; ../Middlewares/ST/STM32_WPAN/zigbee/platform; ../Middlewares/ST/STM32_WPAN/zigbee/core/inc; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lic_module_zigbee_mcu.bin
  prebuild: Build_script.exe startup_stm32wb55xx_cm4.s
  ILINK.IlinkOutputFile: lic_module_zigbee_mcu.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c hw_timerserver.c hw_uart.c stm32_lpm_if.c stm_logging.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_zigbee.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_hsem.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/zigbee/lib/: stm32wb_zigbee_wb_lib.a
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c tl_zigbee_hci.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/zigbee/platform/: ee.c hw_flash.c
    ../Middlewares/ST/STM32_WPAN/zigbee/core/src/: zigbee_core_wb.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
