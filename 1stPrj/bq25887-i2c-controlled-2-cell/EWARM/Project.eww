<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LIC_BQ25887_I2C.ewp</path>
  </project>
  <batchBuild />
</workspace>
