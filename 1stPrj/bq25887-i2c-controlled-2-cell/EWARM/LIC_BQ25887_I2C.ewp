# IAR project LIC_BQ25887_I2C.ewp, settings and files
configuration LIC_BQ25887_I2C (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VC ST STM32F207VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LIC_BQ25887_I2C.hex
  ILINK.IlinkOutputFile: LIC_BQ25887_I2C.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: BQ25887.c main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c
