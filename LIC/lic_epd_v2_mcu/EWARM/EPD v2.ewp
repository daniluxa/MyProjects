# IAR project EPD v2.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; REGION_RU864; USER_VECT_TAB_ADDRESS
  ICCARM.CCIncludePath2: ../LWIP/App; ../LWIP/Target; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Core/Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/lan8742; ..\Middlewares\Third_Party; ..\Middlewares\Third_Party\LwIP\src\include\lwip\apps; ..\LoRaWAN\App\inc; ..\Middlewares\Third_Party\LoRaWAN\Utilities; ..\Middlewares\Third_Party\LoRaWAN\Phy; ..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic; ..\Middlewares\Third_Party\LoRaWAN\Mac; ..\Middlewares\Third_Party\LoRaWAN\Mac\region; ..\Middlewares\Third_Party\LoRaWAN\Crypto; ..\Middlewares\Third_Party\LoRaWAN\Conf\Inc; ..\LoRaWAN\App\inc; ..\LoRaWAN\Phy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EPD v2.bin
  prebuild: Build_script.exe startup_stm32f407xx.s
  ILINK.IlinkOutputFile: EPD v2.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\Middlewares\Third_Party\LwIP\lwip.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; REGION_RU864
  ICCARM.CCIncludePath2: ../LWIP/App; ../LWIP/Target; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Core/Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../LoRaWAN_lib/Inc; ../LoRaWAN_lib/Inc/Utilities; ../LoRaWAN_lib/Inc/LoRaWAN; ../LoRaWAN_lib/Inc/LoRaWAN/Region; ../Drivers/BSP/Components/lan8742; ..\Middlewares\Third_Party; ..\Middlewares\Third_Party\LwIP\src\include\lwip\apps
  OBJCOPY.OOCOutputFile: EPD v2.hex
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Components
    ../Core/Src/: ads1220_lib.c at24mac402.c BQ25887.c eeprom_lib.c gps.c lib_LIS3DH.c SC_lib.c sound.c W25Qxx.c
  group Application/User/Core
    ../Core/Src/: init.c inputs.c magma.c main.c sensors.c some_stuff.c stm32f4xx_hal_msp.c stm32f4xx_it.c timers.c zigbee.c
  group Application/User/LoRaWAN/App
    ../Core/Src/: lora_stuff.c
  group Application/User/LoRaWAN/Basic
    ../Middlewares/Third_Party/LoRaWAN/Patterns/Basic/: lora-test.c lora.c
  group Application/User/LoRaWAN/Crypto
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
  group Application/User/LoRaWAN/End_Node
    ../LoRaWAN/App/src/: hw_gpio.c hw_rtc.c hw_spi.c
  group Application/User/LoRaWAN/Mac
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Application/User/LoRaWAN/Mac/Region
    ../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionCommon.c RegionEU868.c RegionRU864.c
  group Application/User/LoRaWAN/Phy
    ../LoRaWAN/Phy/: radio.c sx126x.c sx126x_hal.c
  group Application/User/LoRaWAN/Utilities
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c systime.c timeServer.c utilities.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
    ../Core/Src/: mqtt_callbacks.c mqtt_stuff.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
